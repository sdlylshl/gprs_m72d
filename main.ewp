# IAR project main.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    Source/: Clock.c Flash.c Global.h GSM_General.c main.c Open_Box.c PortIO.c PortIO.h Strategy.c Timer.c U_use.c
    测试说明/: xiugaijilu.c
  group GPS
    Source/GPS/: Do_GPS_Data.c GPS.c GPS.h GPS_ANT.c
  group GSM
    Source/GSM/: Call_MCU.c GSM.c GSM.h GSM_Brust.c GSM_CMD.c GSM_CONFIG.c GSM_Heart_Beat.c GSM_Init.c GSM_RD_Data.c GSM_SendData.c GSM_Status.c GSM_String.c IP_Port_Set.c Lock_Monitor.c Low_Pow_Time.c MCU_Time.c OUT_EDGE.c SIM_CARD.c SM_GPS.c SOFT_VSION.c Up_Speed.c Work_Mode.c
  group SPI
    Source/SPI/: CRC modbus.c CRC modbus.h shuzu.h SPI.h SPIB2 init.c SPIB2 init.h
  group UP
    Source/GSM/UP/: Ce_Shi_UP.c Root_Up.h Root_Up_Begin.c Up_C.c UP_Num_CRC.c UP_OK_ANS.c UP_SPI_Num.c Up_Stat_2_Net.c
